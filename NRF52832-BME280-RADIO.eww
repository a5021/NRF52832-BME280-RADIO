<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\IDE\iar\NRF52832-BME280-RADIO.ewd</path>
    </project>
    <batchBuild />
</workspace>
