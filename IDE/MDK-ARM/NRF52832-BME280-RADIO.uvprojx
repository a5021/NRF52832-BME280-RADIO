# Keil uVision project NRF52832-BME280-RADIO.uvprojx, settings and files
target E73 (6140000::V6.14::ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=2 uC99=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=2
  c define: FLOAT_ABI_HARD CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA __HEAP_SIZE=2048 __STACK_SIZE=2048 USE_UART
  c include: ..\..\..
  asm define: FLOAT_ABI_HARD NRF52 NRF52832_XXAA __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group app
    ../../: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 8.32.1
